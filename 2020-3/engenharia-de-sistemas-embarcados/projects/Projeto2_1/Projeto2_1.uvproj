# Keil uVision project Projeto2_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: Projeto2_1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./C/: projeto2_1.c
